Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-30T22:35:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 22:35:27 2023 * Host: DESKTOP-D2DSTPK * Database: C:\Users\WINDOWS\AppData\Local\Temp\3e457ab1-953c-47fd-b30b-2f2c4a99cde3\d14209cc-b1d9-4562-bfb6-5b876c2bc67f\ifc * Database version: 5507 * Database creation date: Thu Mar 30 22:35:26 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 22:35:26 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 22:35:26 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (3)
Description: Flow
Name | FlowDirection
2 x Port_347220 | SOURCE
Port_347220 | SINK

# IfcFlowTerminal: FFAS0911-601500BF0_REVIT:Milano exposed bath & shower mixer (conv, FFAS0911-601500BF0_REVIT:Milano exposed bath & shower mixer (conv:347220
In: Level 1
Material: Brass
Pset_DistributionFlowElementCommon - Reference: Milano exposed bath & shower mixer (conv; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_ProductRequirements - Category: Plumbing Fixtures
